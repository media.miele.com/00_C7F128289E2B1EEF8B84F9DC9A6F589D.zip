Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-06-10T09:44:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 10 09:44:31 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\1b315791-7c3b-4836-9d31-c56657616e7e\c9efc120-49bf-411e-8324-8b5188eeb23f\ifc * Database version: 5507 * Database creation date: Mon Jun 10 09:44:30 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 10 09:44:30 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 10 09:44:30 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12443630_AUS_KWTS4785F_OBSW:39478562_AUS_12443630_KWTS4785F_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 39478562_AUS_12443630_KWTS4785F_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 39478562_AUS_12443630_KWTS4785F_OBSW
Material: z_Miele_Design_CLST, z_Miele_Design_OBSW, Spruce, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass Black, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - sets with these values: 2
